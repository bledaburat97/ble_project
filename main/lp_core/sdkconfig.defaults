## main/lp_core/sdkconfig.defaults
```kconfig
CONFIG_ULP_LP_CORE=y
CONFIG_ULP_LP_CORE_I2C_ENABLE=y
CONFIG_LP_I2C_ENABLE=y
CONFIG_LP_I2C_MASTER_ENABLE=y
CONFIG_ULP_LP_CORE_USE_LP_I2C=y
```
